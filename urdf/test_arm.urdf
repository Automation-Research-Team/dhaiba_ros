Commit message: Merge dhaiba_pybind into dhaiba_ros and add README.md

File: urdf/test_arm.urdf (robot description, URDF)
Before this commit: robot test_arm, 1 links, 0 joints
Links:
- removed link world
- added link base_link
